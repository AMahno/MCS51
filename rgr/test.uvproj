# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: EFM8SB10F8G-QFN24 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(25000000)
  output: test
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: SILABS_STARTUP.A51
